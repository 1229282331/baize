## firmware/boot/boards/baize/baize_chassis/board.yml
```yaml
board:
  name: baize_chassis
  full_name: Baize STM32F103 chassis
  vendor: others
  socs:
    - name: stm32f103xe
```
